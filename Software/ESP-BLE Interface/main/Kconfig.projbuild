## Software/ESP-BLE Interface/main/Kconfig.projbuild
```kconfig
menu "NETESP Config"

config SIM_MODE
    bool "Enable simulated transport (no CANESP required)"
    default y

endmenu
```
